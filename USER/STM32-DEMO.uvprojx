# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;.\BxHwCfg;.\E2PROM;.\PVMap;.\DataExch;.\Maths;.\BoxFun;.\BoxApp;.\IMU;.\StmFlash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c
    ./BxHwCfg/: HwCfg.c
    ./PVMap/: IOMap.c
    ./BoxApp/: BoxApp.c
    ./StmFlash/: stm32f10x_flash.c stm_flash.c
    ./BoxFun/: BoxFun.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c
    ./: stm32f10x_it.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
software components: CMSIS:CORE 5.1.1
